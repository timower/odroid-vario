COMPATIBLE_MACHINE:vario-odroidc4 = "vario-odroidc4"
MODEL:vario-odroidc4 = "odroid-c4"

